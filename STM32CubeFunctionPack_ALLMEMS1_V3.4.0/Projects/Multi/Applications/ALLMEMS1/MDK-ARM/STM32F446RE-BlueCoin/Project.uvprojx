# Keil uVision project Project.uvprojx, settings and files
target ALLMEMS1_STM32446E_BlueCoin (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ALLMEMS1_BC +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32F4XX_NUCLEO,STM32_BLUECOIN,USE_BLUECOIN,ARM_MATH_CM4,ALLMEMS1
  c misc: --reduce_paths
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\BSP\BlueCoin;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsm;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\ST\STM32_Audio\Addons\PDM\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionAR_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MotionFX_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_AcousticBF_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_AcousticSL_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueVoiceADPCM_Library\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_BlueNRG\Interface
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329 --reduce_paths
  group MDK-ARM
    ./: startup_stm32f446xx.s
  group User
    ../../Src/: AcousticBF_Manager.c AcousticSL_Manager.c AudioBV_Manager.c console.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionFX_Manager.c OTA.c sensor_service.c stm32f4xx_hal_msp.c stm32f4xx_it.c TargetPlatform.c
  group Doc
    ../../: readme.txt
  group Drivers/BSP/BlueCoin
    ../../../../../../Drivers/BSP/BlueCoin/: BlueCoin.c BlueCoin_accelero.c BlueCoin_audio_in.c BlueCoin_BlueNRG.c BlueCoin_gyro.c BlueCoin_magneto.c BlueCoin_pressure.c BlueCoin_temperature.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_sdmmc.c
  group Middlewares/STM32_BlueNRG
    ../../../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gatt_aci.c bluenrg_gap_aci.c bluenrg_l2cap_aci.c bluenrg_hal_aci.c bluenrg_utils_small.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c hci_le.c
    ../../../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: gp_timer.c osal.c ble_list.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group STM32_Audio_PDM
    ../../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil.lib
  group Middlewares/ST/STM32_MotionXX
    ../../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR200_CM4F_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX200_CM4F_Keil_ot.lib
  group Middlewares/ST/STM32_AcousticXX
    ../../../../../../Middlewares/ST/STM32_AcousticBF_Library/Lib/: acoustic_BF_CM4F_Keil_ot.lib
    ../../../../../../Middlewares/ST/STM32_AcousticSL_Library/Lib/: acoustic_SL_CM4F_Keil_ot.lib
  group Middlewares/ST/STM32_BlueVoiceADPCM
    ../../../../../../Middlewares/ST/STM32_BlueVoiceADPCM_Library/Lib/: bluevoiceADPCM_200_CM4F_Keil_ot.lib
software components: CMSIS:CORE 4.1.0
